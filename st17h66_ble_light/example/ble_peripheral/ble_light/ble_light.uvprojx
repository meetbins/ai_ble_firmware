# Keil uVision project ble_light.uvprojx, settings and files
target ble_light (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.8.0
  cpu: IRAM(0x20000000,0x20000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: ble_light +hex
  AfterMake: fromelf.exe .\Objects\ble_light.axf --i32combined --output .\bin\ble_light.hex
  AfterMake: fromelf -c -a -d -e -v -o ble_light.asm ./Objects/ble_light.axf
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CFG_CP  OSAL_CBTIMER_NUM_TASKS=1 MTU_SIZE=247 HOST_CONFIG=4 HCI_TL_NONE=1 ENABLE_LOG_ROM_=0  _BUILD_FOR_DTM_=0 DEBUG_INFO=1 DBG_ROM_MAIN=0 APP_CFG=0  OSALMEM_METRICS=0 PHY_MCU_TYPE=MCU_BUMBEE_M0 CFG_SLEEP_MODE=PWR_MODE_SLEEP CFG_HCLK_DYNAMIC_CHANGE=0 DEF_GAPBOND_MGR_ENABLE=0 USE_FS=0 MAX_NUM_LL_CONN=1 GATT_MAX_NUM_CONN = MAX_NUM_LL_CONN+1
  c misc: -DADV_NCONN_CFG=0x01  -DADV_CONN_CFG=0x02  -DSCAN_CFG=0x04   -DINIT_CFG=0x08   -DBROADCASTER_CFG=0x01 -DOBSERVER_CFG=0x02  -DPERIPHERAL_CFG=0x04  -DCENTRAL_CFG=0x08
  c include: ..\..\..\..\..\ai_blemesh_firmware\st17h66\components\inc;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\ble\controller;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\osal\include;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\common;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\ble\include;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\ble\hci;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\ble\host;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\Profiles\ota_app;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\Profiles\DevInfo;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\Profiles\SimpleProfile;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\Profiles\Roles;.\source;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\libraries\crc16;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\libraries\ll_patch;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\watchdog;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\clock;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\arch\cm0;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\pwrmgr;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\uart;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\gpio;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\timer;..\..\..\..\..\ai_blemesh_firmware\st17h66\misc;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\log;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\libraries\cliface;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\key;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\pwm;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\flash;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\libraries\fs;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\led_light;..\..\..\..\..\ai_blemesh_firmware\st17h66\components\driver\spi
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x400
  memory RVCT5: ROM 0x1fff8000 size 0x1f40
  memory RVCT9: RAM 0x1fff6000 size 0x2000
  scatter file: .\scatter_load.sct
  link misc: ..\..\..\..\..\ai_blemesh_firmware\st17h66\misc\bb_rom_sym_m0.txt  --keep=jump_table_base  --keep=global_config
  group arch
    ./: main.c
  group driver
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/uart/: uart.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/clock/: clock.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/gpio/: gpio.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/timer/: timer.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/watchdog/: watchdog.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/pwrmgr/: pwrmgr.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/log/: my_printf.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/key/: key.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/pwm/: pwm.c
    ../../../../../ai_blemesh_firmware/st17h66/components/osal/snv/: osal_snv.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/flash/: flash.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/led_light/: led_light.c
    ../../../../../ai_blemesh_firmware/st17h66/components/driver/spi/: spi.c
  group profile
    ../../../../../ai_blemesh_firmware/st17h66/components/profiles/Roles/: central.c gap.c gapbondmgr.c gapgattserver.c peripheral.c
    ../../../../../ai_blemesh_firmware/st17h66/components/profiles/GATT/: gattservapp.c
  group jump
    ../../../../../ai_blemesh_firmware/st17h66/misc/: jump_table.c
  group lib
    ../../../../../ai_blemesh_firmware/st17h66/lib/: rf.lib ble_host.lib
    ../../../../../ai_blemesh_firmware/st17h66/components/libraries/ll_patch/: ll_patch.c
  group ble_light
    ./source/: OSAL_BLELamp.c ble_lamp_app.c app_main.c ble_lamp_service.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1
